# Keil uVision project uart2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C4052AD STC
  output: uart2
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: uart2.c
